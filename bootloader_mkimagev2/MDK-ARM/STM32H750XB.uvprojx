# Keil uVision project STM32H750XB.uvprojx, settings and files
target STM32H750XB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H750XB +hex
  AfterMake: D:\software_work\keil5\ARM\ARMCC\bin\fromelf.exe  --bin -o  ./STM32H750XB/STM32H750XB.bin  ./STM32H750XB/STM32H750XB.axf
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../BSP;../BOOT;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../shell/include;../shell/cmd;../zmodem/file;../zmodem;../shell/cmd/all_cmd_interface;../software_aes_cbc;../AES;../interface;..\AES\include;..\AES\cipher;..\AES\legacy_v3\include\cipher;..\AES\include\cipher;..\AES\legacy_v3\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c cryp.c fmc.c quadspi.c sdmmc.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_qspi.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group BSP
    ../BSP/: bsp_tick.c bsp_led.c bsp_qspi.c bsp_usart.c bsp_sd.c bsp_sdram.c bsp_key.c bsp_information.c
  group API
    ../interface/: api_information.c api_led.c api_qspi.c api_sdram.c api_uart.c
  group BOOT
    ../BOOT/: boot.c boot_head.c boot_start.c boot_update.c bootloader.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group config.h
    ../BOOT/: config.h
  group shell
    ../shell/src/: shell.c parser.c command.c
    ../shell/cmd/: cmd_help.c cmd_clear.c cmd_crc32.c cmd_flash.c cmd_go.c cmd_ram.c cmd_reboot.c cmd_setenv.c
    ../shell/cmd/all_cmd_interface/: interface_cmd.c
  group rz
    ../zmodem/: crctab.c lrz.c mrz.c rbsb.c zm.c zreadline.c
    ../zmodem/file/: file.c
  group aes
    ../AES/: aes.c test.c aes_process.c cmox_low_level.c libSTM32Cryptographic_CM7.a
software components: CMSIS:CORE 4.3.0
